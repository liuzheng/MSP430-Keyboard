# IAR project USB_KBD.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F5510 MSP430F5510
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 1
  ICC430.newCCIncludePaths: ..\Src\; ..\Src\Include; ..\Src\USB_Config; ..\Src\USB_API; ..\Src\USB_App; ..\Src\F5xx_F6xx_Core_Lib; ..\Src\driverlib\MSP430F5xx_6xx
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: CONFIG\lnk430_usbkbd_5510.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group CONFIG
    CONFIG/: lnk430_usbkbd_5510.xcl
  group Libs/driverlib/MSP430F5xx_6xx
    ../Src/driverlib/MSP430F5xx_6xx/: adc10_a.c adc10_a.h adc12_a.c adc12_a.h aes.c aes.h bak_batt.c bak_batt.h comp_b.c comp_b.h crc.c crc.h dac12_a.c dac12_a.h dma.c dma.h driverlib.h eusci_a_spi.c eusci_a_spi.h eusci_a_uart.c eusci_a_uart.h eusci_b_i2c.c eusci_b_i2c.h eusci_b_spi.c eusci_b_spi.h eusci_i2c.c eusci_i2c.h eusci_spi.c eusci_spi.h eusci_uart.c eusci_uart.h flash.c flash.h gpio.c gpio.h ldopwr.c ldopwr.h mpy32.c mpy32.h pmap.c pmap.h pmm.c pmm.h ram.c ram.h ref.c ref.h rtc_a.c rtc_a.h rtc_b.c rtc_b.h rtc_c.c rtc_c.h sd24_b.c sd24_b.h sfr.c sfr.h sys.c sys.h tec.c tec.h timer_a.c timer_a.h timer_b.c timer_b.h timer_d.c timer_d.h tlv.c tlv.h ucs.c ucs.h usci_a_spi.c usci_a_spi.h usci_a_uart.c usci_a_uart.h usci_b_i2c.c usci_b_i2c.h usci_b_spi.c usci_b_spi.h usci_i2c.c usci_i2c.h usci_spi.c usci_spi.h usci_uart.c usci_uart.h wdt_a.c wdt_a.h
  group Libs/USB/USB API/USB_CDC_API
    ../Src/USB_API/USB_CDC_API/: UsbCdc.c UsbCdc.h
  group Libs/USB/USB API/USB_CDC_API/USB_PHDC_API
    ../Src/USB_API/USB_PHDC_API/: UsbPHDC.c UsbPHDC.h
  group Libs/USB/USB API/USB_Common
    ../Src/USB_API/USB_Common/: defMSP430USB.h device.h types.h usb.c usb.h usbdma.c UsbIsr.h
  group Libs/USB/USB API/USB_HID_API
    ../Src/USB_API/USB_HID_API/: UsbHid.c UsbHid.h UsbHidReq.c UsbHidReq.h
  group Libs/USB/USB API/USB_MSC_API
    ../Src/USB_API/USB_MSC_API/: UsbMsc.h UsbMscReq.c UsbMscReq.h UsbMscScsi.c UsbMscScsi.h UsbMscStateMachine.c UsbMscStateMachine.h
  group Libs/USB/USB Config
    ../Src/USB_config/: descriptors.c descriptors.h UsbIsr.c
  group Src
    ../Src/: TI_USBKBD_comm_protocol.c TI_USBKBD_DKS.c TI_USBKBD_HIDKBD_report.c TI_USBKBD_main.c TI_USBKBD_SharedTables.c TI_USBKBD_ticktimer.c
  group Src/Header Files
    ../Src/Include/: TI_USBKBD_comm_protocol_public.h TI_USBKBD_DKS_public.h TI_USBKBD_hardware.h TI_USBKBD_HIDKBD_report_public.h TI_USBKBD_HUT.h TI_USBKBD_public.h TI_USBKBD_public_defs.h TI_USBKBD_ticktimer_public.h
  group Src/USB App
    ../Src/USB_App/: usbConstructs.c usbConstructs.h usbEventHandling.c
